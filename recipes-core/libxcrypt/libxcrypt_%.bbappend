#libxcrypt package is fetching from codelinaro
SRC_URI = "${CLO_LE_GIT}/libxcrypt.git;branch=${SRCBRANCH};protocol=https"
SRCBRANCH = "besser82/develop"

#Fetch the package from the codelinaro
SRC_URI = "${CLO_LE_GIT}/ncurses.git;protocol=https;branch=debian/master"

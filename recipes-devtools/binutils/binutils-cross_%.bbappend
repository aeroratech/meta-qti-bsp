#Below Package is Fetch from the CAF
BINUTILS_GIT_URI = "git://source.codeaurora.org/quic/le/binutils-gdb.git;protocol=https;branch=binutils-gdb/binutils-${BINUPV}-branch"

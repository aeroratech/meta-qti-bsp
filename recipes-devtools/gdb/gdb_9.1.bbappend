
PACKAGECONFIG_remove = "readline"

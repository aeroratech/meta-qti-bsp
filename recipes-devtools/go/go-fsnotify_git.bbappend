#Fetch the package from the codeaurora
SRC_URI = "git://source.codeaurora.org/quic/le/fsnotify/fsnotify.git;protocol=https;branch=fsnotify/main"


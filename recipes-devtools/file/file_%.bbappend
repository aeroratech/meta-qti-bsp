#Package is fetch from the codelinaro
SRC_URI = "${CLO_LE_GIT}/file.git;protocol=https;branch=file/master"

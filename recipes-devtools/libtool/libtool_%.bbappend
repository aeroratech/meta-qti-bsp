#Remove of bash from libtool
RDEPENDS_${PN}_remove = "bash"

export CONFIG_SHELL = "/bin/sh"



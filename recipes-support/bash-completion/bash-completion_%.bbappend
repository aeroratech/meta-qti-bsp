#remove of bash from the bash-completion
RDEPENDS_${PN}_remove = "bash"

#Package is fetching from codelinaro
SRC_URI = "${CLO_LE_GIT}/pps-tools;protocol=https;branch=caf_migration/ago/master"

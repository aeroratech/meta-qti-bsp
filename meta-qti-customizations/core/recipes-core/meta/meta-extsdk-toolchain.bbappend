# Remove dependencies as QTI eSDK don't support qemu. 

DEPENDS_remove = "qemu-native"
DEPENDS_remove = "qemu-helper-native"

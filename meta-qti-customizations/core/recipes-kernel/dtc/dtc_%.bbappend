PROVIDES = "virtual/dtc-native"

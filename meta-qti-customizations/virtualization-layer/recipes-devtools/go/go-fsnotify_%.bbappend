#Fetch the package from the codelinaro
SRC_URI = "${CLO_LE_GIT}/fsnotify/fsnotify.git;protocol=https;branch=caf_migration/fsnotify/main"
